# IAR project hello_hmi.ewp, settings and files
configuration hello_hmi (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ..\..\User_H; ..\..\stm32f103x\inc; ..\..\Core
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hello_hmi.srec
  ILINK.IlinkOutputFile: hello_hmi.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Core
    ../../Core/: startup_stm32f103xb.s startup_stm32f10x_md.s stm32f10x_it.c system_stm32f10x.c
  group stm32f10x
    ../../stm32f103x/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User_C
    ../../User_C/: 24CXX.c buzz.c crc.c DataExchange.c DataHandle.c delay.c faultProcess.c IIC.c Interrupt_Init.c key.c LCD_display.c led.c main.c Menu.c rtc.c struct_comm.c SysPr.c SystemInit.c SystemWord.c timer.c usart.c ziku.c
