# Keil uVision project I_Washing_M_20161018.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WASH +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\User_H;..\stm32f103x\inc;..\Core
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User_C
    ../User_C/: Menu.c main.c timer.c SystemInit.c usart.c SysPr.c IIC.c 24CXX.c delay.c ziku.c rtc.c Interrupt_Init.c key.c crc.c SystemWord.c LCD_display.c led.c buzz.c DataExchange.c DataHandle.c struct_comm.c faultProcess.c
  group stm32f10x
    ../stm32f103x/src/: misc.c stm32f10x_adc.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_gpio.c stm32f10x_sdio.c
  group Core
    ../Core/: startup_stm32f10x_md.s system_stm32f10x.c stm32f10x_it.c
